# Keil uVision project Motor Bridge Firmware.uvprojx, settings and files
target Motor Bridge Firmware (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MotorBridgeFirmware +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\Objects\MotorBridgeFirmware.bin .\Objects\MotorBridgeFirmware.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030
  c include: .\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\CMSIS\Include;.\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\User;.\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\STM32F0xx_CPAL_Driver\inc;.\Motor
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./User/: main.c stm32f0xx_it.c init.c led.c communication.c
  group StdPeriphLib
    ./STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group CMSIS
    ./STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ./STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
  group Motor
    ./User/: TB6612FNG.c
    ./Motor/: motor_dc.c motor_stepper.c motor_servo.c
